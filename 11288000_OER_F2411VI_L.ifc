Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-11-09T11:04:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 09 11:04:37 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\0dd32ffb-e798-4f23-a96e-312fa1f5c011\fe254f46-a9f7-4e78-b353-9f433eec91e1\ifc * Database version: 5507 * Database creation date: Wed Nov 09 11:04:36 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Nov 09 11:04:36 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 09 11:04:36 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11288000_OER_F2411VI_L:37241101_OER_11288000_F2411VI_L, (2)
In: Default
Type - Material: z_Miele_Design_GRGR
Type - Pset_BuildingElementProxyCommon - Reference: 37241101_OER_11288000_F2411VI_L
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Freezers / freezers
Type - Pset_QuantityTakeOff - Reference: 37241101_OER_11288000_F2411VI_L
Type - Pset_ProvisionForVoid - Width: 451 mm; Height: 2127 mm; Depth: 610 mm
Material: z_Miele_Design_GRGR, z_Miele_Design_Powder Coat_Lotus White, z_Miele_Design_Glass Black, z_Miele_Connection_Water_IN, z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Design_OBSW, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment

# IfcDistributionPort, Port_358006
Description: Flow; FlowDirection: SOURCEANDSINK
